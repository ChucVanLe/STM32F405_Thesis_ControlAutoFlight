# Keil uVision project crc.uvproj, settings and files
target CRC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: crc
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: HSE_VALUE=8000000,USE_STDPERIPH_DRIVER
  c include: ..\file.c;..\file.h;..\filestmf405.c;..\lib\inc;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ../lib/: startup_stm32f4xx.s
  group CMSIS
    ../lib/: system_stm32f4xx.c stm32f4xx.h system_stm32f4xx.h
  group stm32f4xx-stdperiph-Driver
    ../lib/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group User
    ../filestmf405.c/: diskio05.c peripheral05.c pid05.c powersd05.c luanvan3-05vs2.c core.c LL2UTM.c gps.c ConnectWithGS.c
  group SD
    ../Sd Card/: fattime.c ff.c
    ../Sd Card/option/: ccsbcs.c
    ../file.h/: ffconf.h diskio.h
  group user.h
    ../file.h/: powersd.h project.h
